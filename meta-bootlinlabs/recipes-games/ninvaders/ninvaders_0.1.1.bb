require ninvaders.inc

LICENSE = "GPLv1"
LIC_FILES_CHKSUM = "file://README;md5=62f2ab9779d8f2b6bce96bdbad303623"
SRC_URI[md5sum] = "97b2c3fb082241ab5c56ab728522622b"
